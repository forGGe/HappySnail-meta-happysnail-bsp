FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://hs-bsp-tree.dts;subdir=git/arch/arm/dts"
