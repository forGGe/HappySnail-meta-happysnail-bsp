FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://gawk5.patch"
